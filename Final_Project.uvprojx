# Keil uVision project Final_Project.uvprojx, settings and files
target Core (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Final_Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Inc
    ./Firmware/Core/Inc/: main.h
  group Src
    ./Firmware/Core/Src/: main.c
  group mcu_drivers
    ./Firmware/mcu_drivers/inc/: drv_gpio.h drv_pwm.h drv_timer.h drv_uart.h
    ./Firmware/mcu_drivers/src/: drv_gpio.c drv_pwm.c drv_timer.c drv_uart.c
  group platform
    ./Firmware/platform/inc/: actuator_hal.h comm_hal.h sensor_hal.h soft_timer.h
    ./Firmware/platform/src/: actuator_hal.c comm_hal.c sensor_hal.c soft_timer.c
  group application
    ./Firmware/application/inc/: app_config.h control_app.h greenhouse_types.h pid_control.h protocol_handler.h sensor_app.h
    ./Firmware/application/src/: control_app.c pid_control.c protocol_handler.c sensor_app.c
  group common
    ./Firmware/common/inc/: frame_common.h frame_queue.h queue_manager.h
    ./Firmware/common/src/: frame_queue.c queue_manager.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
